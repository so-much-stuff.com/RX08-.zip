# EAGLE board RX08- (EAGLE 4.11), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
RX_12_BIT\ (continued)
  Bottom 0.254: R16.2 24.77,22.86 23.5,22.86 R7.1 22.23,22.86 20.95,21.59 12.06,21.59 10.79,22.86 DRIVE.FF
RX_DATA
  Top 0.254: E22.2 121.28,40.01 120.02,40.01 E22.3
  Bottom 0.254: E35.1 48.9,41.27 49.53,41.91 80.01,41.91 80.64,42.55 117.47,42.55 118.75,41.27 E22.3
RX_DATA\
  Top 0.254: R8.1 18.41,22.86 19.68,22.86 R17.2 | E37.6 35.56,74.93 26.67,66.04 26.67,46.35 19.05,38.73 19.05,34.92 12.06,27.94 10.79,27.94 DRIVE.BB
  Bottom 0.254: 13.34,27.94 10.79,27.94 DRIVE.BB | 13.34,27.94 22.23,27.94 29.21,34.92 38.1,34.92 39.37,36.2 41.27,36.2 45.09,40.01 E35.2 | 13.34,27.94 17.78,23.5 R8.1
RX_DONE\
  Top 0.254: R13.2 24.77,48.26 23.5,48.26 R4.1 22.86,47.62 22.86,46.35 10.16,33.66 DRIVE.X
  Bottom 0.254: E36.8 32.38,48.26 26.04,48.26 R13.2
RX_ERROR\
  Top 0.254: R5.1 19.68,48.26 18.41,48.26 R14.2 17.14,48.26 10.79,48.26 DRIVE.J
  Bottom 0.254: E36.3 42.55,55.24 41.27,53.98 34.92,53.98 34.29,54.61 34.29,57.78 30.48,57.78 20.95,48.26 R5.1
RX_INIT\
  Bottom 0.254: 8.89,41.91 8.89,43.18 9.53,43.18 DRIVE.N | 8.89,41.91 8.89,37.47 9.53,36.83 10.79,36.83 13.34,34.29 20.95,34.29 22.23,35.56 R9.1 | 8.89,41.91 3.81,41.91 3.81,76.83 6.99,80.01 26.04,80.01 27.94,78.11 41.27,78.11 42.55,76.83 E37.3
RX_OUT\
  Top 0.254: R12.2 28.57,22.86 29.84,22.86 R3.1 30.48,23.5 30.48,29.21 33.02,31.75 E35.8
  Bottom 0.254: DRIVE.RR 10.79,12.7 19.05,20.95 25.4,20.95 27.3,22.86 R12.2
RX_RUN\  (via drill 0.61)
  Top 0.254: v18.41,60.96 10.79,53.34 DRIVE.D
  Bottom 0.254: 64.14,63.5 61.59,60.96 R6.1 60.33,60.96 v18.41,60.96 | 64.14,63.5 65.41,63.5 R15.2 | 64.14,63.5 63.5,63.5 63.5,67.31 E33.11
RX_SHIFT\
  Top 0.254: R2.1 27.3,35.56 26.04,35.56 R10.2 25.4,34.92 25.4,33.02 21.59,29.21 21.59,17.78 10.79,17.78 DRIVE.LL
  Bottom 0.254: E35.5 38.1,39.37 38.1,36.2 27.94,36.2 R2.1
RX_TR_REQ\  (via drill 0.61)
  Top 0.254: v36.83,38.73 36.83,53.34 38.1,54.61 E36.5
  Bottom 0.254: v36.83,38.73 34.92,36.83 22.23,36.83 20.95,35.56 R1.1 19.68,35.56 18.41,35.56 R11.2 17.14,35.56 13.34,35.56 10.79,38.1 DRIVE.T
SDN4\  (via drill 0.61)
  Top 0.254: v151.13,33.02 149.86,34.29 149.86,56.52 145.41,60.96 134.62,60.96 134.62,62.23 E18.8
  Bottom 0.254: v151.13,33.02 160.02,33.02 161.93,31.11 E13.10
SER4\  (via drill 0.61)
  Top 0.254: v154.31,34.29 153.67,34.92 v153.67,72.39
  Bottom 0.254: v154.31,34.29 161.29,34.29 164.47,31.11 E13.11 | v153.67,72.39 153.03,73.03 141.6,73.03 140.34,71.75 E18.5
SHIFT
  Top 0.254: E35.4 41.27,41.27 42.55,42.55 49.53,42.55 49.53,33.66 50.16,33.02 57.15,33.02 57.15,72.39 59.69,74.93 59.69,88.27 81.92,110.49 91.44,110.49 91.44,102.87 E32.3
STR2\  (via drill 0.61)
  Top 0.254: v156.84,71.12 156.84,55.88 161.29,51.44 161.29,45.09 166.37,40.01 166.37,20.32 167.64,19.05 E12.12
  Bottom 0.254: v156.84,71.12 151.76,71.12 151.13,70.48 151.13,69.22 149.22,69.22 147.96,70.48 E18.2
TR_SKIP  (via drill 0.61)
  Top 0.254: E18.1 149.86,72.39 149.86,77.47 E19.16 149.22,79.38 148.59,80.01 | v120.65,89.53 120.65,99.06 119.38,100.33 E26.2 | v146.69,81.92 148.59,80.01 | 148.59,80.01 148.59,95.25 149.22,95.89 149.22,99.69 149.86,100.33 E20.1
  Bottom 0.254: v120.65,89.53 121.92,88.27 124.46,88.27 130.81,81.92 v146.69,81.92
VCC  (via drill 0.61)
  Top 0.508: E28.14 96.52,31.75 97.79,30.48 97.79,20.95 99.06,19.68 C27.1 99.69,19.05 v104.78,13.97 | E29.14 96.52,46.99 97.79,45.72 97.79,36.2 99.06,34.92 C28.1 | 97.79,76.2 97.79,66.04 96.52,64.77 E30.14 97.16,63.5 98.42,63.5 C30.1 99.06,62.87 99.06,60.33 100.33,59.05 100.33,51.44 99.06,50.16 C29.1 | 97.79,76.2 96.52,77.47 E31.14 | 97.79,76.2 97.79,91.44 96.52,92.71 E32.14 | C35.1 50.8,34.92 50.8,36.2 52.07,37.47 52.07,46.35 50.8,47.62 C36.1 50.16,48.26 48.9,48.26 E36.14 48.26,49.53 46.99,50.8 46.99,52.07 46.99,66.04 48.26,67.31 E37.14 | R4.2 22.23,38.1 20.95,38.1 R5.2 20.32,37.47 21.59,36.2 21.59,30.48 20.32,29.21 20.32,26.04 R1.2 | R7.2 22.86,13.34 24.13,14.61 24.13,23.5 22.86,24.77 R9.2 | E30.10 86.36,64.77 88.9,67.31 88.9,69.85 E30.4 | R6.2 71.12,61.59 71.12,67.31 E33.14 71.12,69.85 69.85,71.12 69.85,83.19 | 69.85,83.19 73.66,87 73.66,94.61 C34.1 | 69.85,83.19 68.58,81.92 R18.2 | E11.16 177.8,6.35 176.53,7.62 176.53,15.24 177.8,16.51 E12.16 | E13.16 177.8,29.21 179.07,27.94 179.07,22.23 180.34,20.95 180.34,19.68 C12.1 | E14.6 165.74,55.24 170.81,50.16 177.8,50.16 177.8,49.53 E14.16 | v149.86,58.42 149.86,62.23 E18.14 | C13.1 180.34,32.38 181.61,33.66 181.61,45.72 180.34,46.99 180.34,48.9 C14.1 | 123.19,76.2 121.92,77.47 E25.14 | 123.19,76.2 125.73,73.66 125.73,66.67 124.46,65.41 C24.1 124.46,64.14 125.73,62.87 125.73,52.7 124.46,51.44 124.46,49.53 E23.16 124.46,46.99 125.73,45.72 125.73,30.48 | 123.19,90.81 123.19,76.2 | 123.19,90.81 123.19,91.44 121.92,92.71 E26.14 | 125.73,30.48 125.73,20.95 127,19.68 C21.1 | 125.73,30.48 124.46,31.75 E22.16 | C19.1 152.4,85.72 152.4,94.61 C20.1
  Top 0.508: E19.5 139.7,87.63 v139.7,90.17 139.7,92.71 E20.10 | 166.37,99.69 167,99.69 167,100.97 E17.5 | 166.37,99.69 164.47,99.69 163.19,100.97 E17.7 | E16.10 165.1,80.01 167.64,82.55 167.64,85.09 E16.4 167.64,87.63 166.37,88.9 166.37,99.69 | C15.1 177.8,66.67 176.53,67.94 176.53,76.2 175.26,77.47 E16.14 | C1.1 231.14,9.53 229.87,10.79 229.87,17.78 228.6,19.05 E2.14 228.6,21.59 228.6,26.67 E2.1 228.6,29.21 228.6,31.11 231.14,33.66 C3.1 231.14,34.92 233.68,37.47 233.68,46.35 C4.1 233.68,47.62 234.95,48.9 234.95,56.52 233.68,57.78 R19.1 233.68,59.05 232.41,60.33 | C10.1 205.74,94.61 205.74,83.19 208.28,80.64 C9.1 208.28,79.38 208.28,67.94 205.74,65.41 C8.1 | 232.41,60.33 231.14,61.59 231.14,64.14 C5.1 | 232.41,78.11 231.14,79.38 C6.1 | 232.41,78.11 232.41,60.33 | 232.41,78.11 232.41,93.34 231.14,94.61 C7.1 | v124.46,90.81 123.19,90.81
  Bottom 0.508: E29.14 97.16,48.9 97.79,49.53 98.42,49.53 C29.1 | E27.14 97.16,18.41 97.79,19.05 98.42,19.05 C27.1 | E28.14 97.16,33.66 97.79,34.29 98.42,34.29 C28.1 | C32.1 98.42,95.25 97.79,95.25 97.16,94.61 E32.14 95.89,94.61 94.61,95.89 73.66,95.89 C34.1 73.03,95.25 53.98,95.25 51.44,92.71 C38.1 50.8,93.34 33.02,93.34 28.57,97.79 C40.1 | E31.14 97.16,79.38 97.79,80.01 98.42,80.01 C31.1 | C35.1 50.16,34.29 49.53,34.29 48.9,33.66 E35.14 47.62,32.38 40.64,25.4 28.57,25.4 R2.2 27.3,25.4 26.04,24.13 24.77,24.13 23.5,25.4 R9.2 22.23,25.4 20.95,25.4 R1.2 | 20.95,13.97 19.68,13.97 18.41,12.7 R8.2 | 20.95,13.97 22.23,12.7 R7.2 | 20.95,13.97 28.57,13.97 29.84,12.7 R3.2 | 27.94,70.48 6.35,70.48 5.71,69.85 C41.1 | 27.94,70.48 C39.1 27.94,70.48 | 27.94,70.48 46.35,70.48 47.62,69.22 E37.14 48.9,69.22 49.53,69.85 50.16,69.85 C37.1 51.44,69.85 52.07,70.48 73.66,70.48 C33.1 73.03,69.85 72.39,69.22 71.75,69.22 E33.14 71.12,67.31 82.55,67.31 85.72,64.14 E30.10 87,64.14 88.27,65.41 89.53,65.41 90.81,64.14 E30.12 | E13.16 178.44,31.11 179.07,31.75 179.71,31.75 C13.1 | E11.16 178.44,5.71 179.07,6.35 179.71,6.35 C11.1 180.97,6.35 182.88,4.45 225.43,4.45 227.97,6.99 E1.14 229.24,8.26 229.87,8.89 230.5,8.89 C1.1 | E12.16 178.44,18.41 179.07,19.05 179.71,19.05 C12.1 | E18.14 150.5,64.14 151.13,64.77 151.76,64.77 C18.1 | E14.16 178.44,48.9 179.07,49.53 179.71,49.53 C14.1 | v149.86,58.42 162.56,58.42 164.47,56.52 E14.6 | E26.14 122.56,94.61 123.19,95.25 123.83,95.25 C26.1 | E24.14 122.56,64.14 123.19,64.77 123.83,64.77 C24.1 | E25.14 122.56,79.38 123.19,80.01 123.83,80.01 C25.1 124.46,80.64 119.38,80.64
  Bottom 0.508: E23.16 125.09,48.9 125.73,49.53 126.36,49.53 C23.1 | C21.1 126.36,19.05 125.73,19.05 125.09,18.41 E21.16 123.83,17.14 121.28,14.61 105.41,14.61 v104.78,13.97 | E22.16 125.09,33.66 125.73,34.29 126.36,34.29 C22.1 | C20.1 151.76,95.25 151.13,94.61 150.5,94.61 E20.14 149.22,93.34 147.32,91.44 140.97,91.44 v139.7,90.17 125.09,90.17 v124.46,90.81 | C17.1 179.71,100.33 179.07,99.69 169.54,99.69 168.28,100.97 E17.5 | E15.14 175.9,65.41 176.53,66.04 177.16,66.04 C15.1 | E16.14 175.9,79.38 176.53,80.01 177.16,80.01 C16.1 | E16.10 165.74,79.38 167,80.64 177.8,80.64 C16.1 | C19.1 153.03,85.09 153.67,84.45 165.74,84.45 167,85.72 E16.4 | 228.6,22.23 231.14,22.23 C2.1 | 228.6,22.23 226.06,22.23 | 226.06,22.23 223.52,22.23 | 223.52,22.23 220.98,22.23 | 220.98,22.23 220.34,22.23 219.07,20.95 E2.10 | 226.06,22.23 226.06,21.59 E2.13 | 228.6,22.23 228.6,21.59 E2.14 | E8.14 203.84,64.14 204.47,64.77 205.1,64.77 C8.1 | E4.16 231.78,46.35 232.41,46.99 233.04,46.99 C4.1 | E5.14 229.24,64.14 229.87,64.77 230.5,64.77 C5.1 | C6.1 230.5,80.01 208.91,80.01 C9.1 207.65,80.01 178.44,80.01 C16.1 | E10.14 203.84,94.61 204.47,95.25 205.1,95.25 C10.1 | E20.9 137.79,93.34 139.06,93.34 E20.10 | 220.98,22.23 220.98,21.59 E2.11 | 223.52,22.23 223.52,21.59 E2.12 | 119.38,80.64 116.2,80.64 114.94,79.38 E25.11 | 119.38,80.64 119.38,80.01 E25.13
WRT  (via drill 0.61)
  Top 0.254: 104.78,110.49 v104.78,90.81 | 104.78,110.49 104.78,111.12 55.88,111.12 46.99,102.23 46.99,97.79 44.45,95.25 44.45,88.27 41.27,85.09 41.27,78.11 40.64,77.47 E37.4 | v158.75,62.87 158.12,63.5 158.12,97.79 157.48,98.42 | 157.48,98.42 145.41,110.49 104.78,110.49 | v188.59,97.16 192.41,100.97 E10.5 | v157.48,97.79 157.48,98.42
  Bottom 0.254: v104.78,90.81 107.31,88.27 117.47,88.27 118.75,87 E25.2 | v158.75,62.87 163.19,62.87 164.47,64.14 E15.10 | v188.59,97.16 187.96,97.79 v157.48,97.79
XDR2  (via drill 0.61)
  Top 0.254: v203.2,67.31 203.2,67.94 204.47,69.22 204.47,97.79 201.29,100.97 E10.2
  Bottom 0.254: 219.71,61.59 215.26,61.59 214,62.87 E5.8 | 219.71,61.59 221.62,61.59 222.88,62.87 E5.12 | v203.2,67.31 203.84,66.67 217.81,66.67 219.71,64.77 219.71,61.59
XDR2\  (via drill 0.61)
  Top 0.254: E25.9 109.22,77.47 110.49,76.2 110.49,69.85 111.12,69.22 113.67,69.22 113.67,70.48 E24.4 | 85.09,1.91 171.45,1.91 171.45,13.97 170.18,15.24 170.18,16.51 E12.13 | 85.09,1.91 60.96,1.91 56.52,6.35 56.52,18.41 43.18,31.75 E35.12 | v95.89,81.92 90.17,81.92 90.17,77.47 85.09,72.39 85.09,1.91 | v205.74,31.11 205.74,34.29 214.63,43.18 214.63,60.96 215.9,62.23 E5.9
  Bottom 0.254: E5.9 216.53,62.87 217.81,62.87 E5.10 | v95.89,81.92 106.05,81.92 108.58,79.38 E25.9 | v205.74,31.11 205.1,31.75 182.25,31.75 180.97,33.02 172.72,33.02 171.45,31.75 171.45,19.05 170.18,19.05 E12.13
XFER_REQ  (via drill 0.61)
  Top 0.254: E19.4 142.24,87.63 144.78,90.17 144.78,92.71 E20.12 | v46.99,96.52 46.99,88.27 41.91,83.19 41.91,58.42 40.64,57.15 E36.4 | v120.02,104.78 121.92,102.87 E26.1 121.92,100.33 123.19,99.06 123.19,94.61 v124.46,93.34
  Bottom 0.254: v46.99,96.52 46.99,104.78 v120.02,104.78 | v124.46,93.34 127,95.89 142.88,95.89 144.15,94.61 E20.12

## Text on the board
Bottom: RX8I Floppy Interface | VRS
tPlace: RX8I Floppy Interface | VRS